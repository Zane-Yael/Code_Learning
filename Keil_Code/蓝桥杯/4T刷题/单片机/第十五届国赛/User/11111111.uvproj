# Keil uVision project 11111111.uvproj, settings and files
target 11111111 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 11111111 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: iic.c iic.h init.c init.h key.c key.h led.c led.h seg.c seg.h ultrasonic.c ultrasonic.h uart.c uart.h
