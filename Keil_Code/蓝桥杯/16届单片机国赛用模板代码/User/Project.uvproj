# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: init.c init.h key.c key.h led.c led.h seg.c seg.h ds1302.c iic.c onewire.c ds1302.h iic.h onewire.h
